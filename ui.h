#pragma once
// ═══════════════════════════════════════════════════════════════
//  ui.h  —  Tablet UI served by the ESP32 web server
//
//  Generated from coin_atm_esp32.html
//  Stored in PROGMEM (flash) — does not consume RAM at runtime
//
//  Usage in main.ino:
//    #include "ui.h"
//    server.on("/", HTTP_GET, []() {
//      server.send(200, "text/html", getUI());
//    });
// ═══════════════════════════════════════════════════════════════

#include <Arduino.h>
#include <pgmspace.h>

const char UI_HTML[] PROGMEM = R"rawhtml(
<!DOCTYPE html>
<html lang="en">
<head>
<meta charset="UTF-8">
<meta name="viewport" content="width=device-width, initial-scale=1.0">
<title>&#x26A1; Sats ATM</title>
<style>
:root {
  --bg:        #0a0e17;
  --surface:   #111827;
  --surface2:  #1a2235;
  --border:    #1f2d45;
  --accent:    #f5a623;
  --accent2:   #f7c564;
  --lightning: #ffe566;
  --green:     #22c55e;
  --amber:     #f59e0b;
  --red:       #ef4444;
  --text:      #f0f4ff;
  --muted:     #6b7fa3;
  --dim:       #3a4a6b;
  --mono:      'Courier New', Courier, monospace;
  --sans:      'Segoe UI', system-ui, -apple-system, sans-serif;
}
* { margin:0; padding:0; box-sizing:border-box; }
body {
  background:var(--bg); color:var(--text); font-family:var(--sans);
  height:100vh; display:flex; flex-direction:column; overflow:hidden;
}
body::before {
  content:''; position:fixed; inset:0;
  background-image: linear-gradient(rgba(245,166,35,0.03) 1px,transparent 1px),
    linear-gradient(90deg,rgba(245,166,35,0.03) 1px,transparent 1px);
  background-size:40px 40px; pointer-events:none; z-index:0;
}

/* TOP BAR */
.topbar {
  position:relative; z-index:10; flex-shrink:0;
  display:flex; align-items:center; justify-content:space-between;
  padding:12px 24px; background:var(--surface); border-bottom:1px solid var(--border);
}
.topbar-left { display:flex; align-items:center; gap:16px; }
.logo {
  display:flex; align-items:center; gap:8px;
  font-family:var(--mono); font-size:14px; font-weight:700;
  color:var(--lightning); letter-spacing:0.05em; user-select:none; cursor:default;
}
.bolt { font-size:18px; filter:drop-shadow(0 0 8px #ffe566aa); animation:pulse-bolt 2s ease-in-out infinite; }
@keyframes pulse-bolt { 0%,100%{filter:drop-shadow(0 0 6px #ffe566aa)} 50%{filter:drop-shadow(0 0 18px #ffe566ff)} }
.rate-badge {
  display:flex; align-items:center; gap:8px; user-select:none;
  background:var(--surface2); border:1px solid var(--border);
  border-radius:8px; padding:5px 12px;
  font-family:var(--mono); font-size:12px; color:var(--accent2);
}
.rate-dot { width:6px; height:6px; border-radius:50%; background:var(--green); box-shadow:0 0 6px var(--green); animation:blink-dot 3s ease-in-out infinite; }
@keyframes blink-dot { 0%,90%,100%{opacity:1} 95%{opacity:0.2} }
.gauge-wrap { display:flex; align-items:center; gap:8px; }
.gauge-label { font-size:10px; color:var(--muted); text-transform:uppercase; letter-spacing:0.1em; }
.gauge-segments { display:flex; gap:4px; }
.seg { width:20px; height:9px; border-radius:3px; transition:all 0.6s ease; }
.seg.green { background:var(--green); box-shadow:0 0 8px var(--green); }
.seg.amber { background:var(--amber); box-shadow:0 0 8px var(--amber); }
.seg.red   { background:var(--red);   box-shadow:0 0 8px var(--red); }
.seg.flash { animation:flash-seg 0.8s ease-in-out infinite; background:var(--red); box-shadow:0 0 8px var(--red); }
.seg.empty { background:var(--dim); box-shadow:none; }
@keyframes flash-seg { 0%,100%{opacity:1} 50%{opacity:0.15} }

/* SETTINGS OVERLAY */
.settings-overlay {
  position:fixed; inset:0; z-index:200;
  background:rgba(10,14,23,0.96);
  display:flex; align-items:center; justify-content:center;
  opacity:0; pointer-events:none; transition:opacity 0.3s;
}
.settings-overlay.show { opacity:1; pointer-events:all; }
.settings-panel {
  background:var(--surface); border:1px solid var(--border);
  border-radius:16px; padding:30px 34px; width:460px; max-width:90vw;
  display:flex; flex-direction:column; gap:18px;
  transform:translateY(20px); transition:transform 0.3s;
}
.settings-overlay.show .settings-panel { transform:translateY(0); }
.settings-title { display:flex; align-items:center; gap:10px; font-size:17px; font-weight:700; color:var(--text); }
.settings-subtitle { font-size:11px; color:var(--muted); margin-top:3px; }
.form-section { display:flex; flex-direction:column; gap:11px; }
.form-section-label {
  font-size:10px; text-transform:uppercase; letter-spacing:0.12em;
  color:var(--muted); padding-bottom:4px; border-bottom:1px solid var(--border);
}
.form-row { display:flex; flex-direction:column; gap:4px; }
.form-label { font-size:11px; color:var(--muted); }
.form-input {
  background:var(--surface2); border:1px solid var(--border);
  border-radius:8px; padding:8px 12px;
  color:var(--text); font-family:var(--mono); font-size:13px;
  width:100%; outline:none; transition:border-color 0.2s;
}
.form-input:focus { border-color:var(--accent); }
.form-input::placeholder { color:var(--dim); }
.pw-wrap { position:relative; }
.pw-wrap .form-input { padding-right:42px; }
.pw-toggle {
  position:absolute; right:10px; top:50%; transform:translateY(-50%);
  background:none; border:none; color:var(--muted); cursor:pointer; font-size:13px; padding:4px;
}
.settings-status {
  font-family:var(--mono); font-size:12px; padding:8px 12px; border-radius:8px;
  background:var(--surface2); border:1px solid var(--border);
  color:var(--muted); min-height:34px; display:flex; align-items:center; gap:8px;
}
.settings-status.ok   { border-color:var(--green); color:var(--green); background:rgba(34,197,94,0.06); }
.settings-status.fail { border-color:var(--red);   color:var(--red);   background:rgba(239,68,68,0.06); }
.settings-status.busy { border-color:var(--amber); color:var(--amber); }
.btn-row { display:flex; gap:8px; justify-content:flex-end; }
.btn {
  font-family:var(--sans); font-size:12px; font-weight:600;
  padding:7px 16px; border-radius:8px; border:1px solid var(--border);
  background:var(--surface2); color:var(--text); cursor:pointer; transition:all 0.2s;
}
.btn:hover    { border-color:var(--accent); color:var(--accent); }
.btn:disabled { opacity:0.4; cursor:not-allowed; }
.btn.primary  { background:var(--accent); border-color:var(--accent); color:#000; font-weight:700; }
.btn.primary:hover { background:var(--accent2); }
.btn.danger   { border-color:rgba(239,68,68,0.4); color:var(--red); }
.btn.danger:hover { background:rgba(239,68,68,0.1); }
.btn.sm { padding:5px 12px; font-size:11px; }
.long-press-hint { font-size:10px; color:var(--dim); text-align:center; margin-top:-6px; }

/* MAIN LAYOUT */
.main {
  position:relative; z-index:10; flex:1;
  display:grid; grid-template-columns:1fr 300px; overflow:hidden;
}

/* LEFT */
.left {
  padding:22px 26px; display:flex; flex-direction:column; gap:18px;
  border-right:1px solid var(--border); overflow-y:auto;
}

/* IDLE */
.idle-screen {
  display:flex; flex-direction:column;
  align-items:center; justify-content:center;
  gap:8px; flex:1; text-align:center;
}
.idle-screen.hidden { display:none; }
.idle-bolt  { font-size:54px; filter:drop-shadow(0 0 24px #ffe566cc); animation:pulse-bolt 2s ease-in-out infinite; }
.idle-title { font-size:26px; font-weight:700; color:var(--text); }
.idle-sub   { font-size:13px; color:var(--muted); }

/* STEPS */
.steps-title { font-size:10px; text-transform:uppercase; letter-spacing:0.15em; color:var(--muted); margin-bottom:9px; }
.steps { display:flex; flex-direction:column; gap:7px; }
.step {
  display:flex; align-items:center; gap:12px; padding:10px 13px;
  background:var(--surface); border:1px solid var(--border);
  border-radius:10px; transition:border-color 0.3s, background 0.3s;
}
.step.active { border-color:var(--accent); background:rgba(245,166,35,0.06); }
.step.done   { border-color:var(--green);  background:rgba(34,197,94,0.05); }
.step-num {
  width:24px; height:24px; border-radius:50%;
  background:var(--surface2); border:1px solid var(--dim);
  display:flex; align-items:center; justify-content:center;
  font-family:var(--mono); font-size:11px; font-weight:700;
  color:var(--muted); flex-shrink:0; transition:all 0.3s;
}
.step.active .step-num { background:var(--accent); border-color:var(--accent); color:#000; }
.step.done   .step-num { background:var(--green);  border-color:var(--green);  color:#000; }
.step-text { font-size:13px; font-weight:600; color:var(--text); }
.step-sub  { font-size:11px; color:var(--muted); margin-top:1px; }
.step.active .step-text { color:var(--accent2); }
.step.done   .step-text { color:var(--green); }

/* TX PANEL */
.tx-panel {
  background:var(--surface); border:1px solid var(--border);
  border-radius:14px; padding:17px 19px;
  display:flex; flex-direction:column; gap:12px; position:relative;
}
.tx-row { display:flex; justify-content:space-between; align-items:center; }
.tx-label { font-size:10px; color:var(--muted); text-transform:uppercase; letter-spacing:0.08em; }
.tx-value { font-family:var(--mono); font-size:18px; font-weight:700; color:var(--text); }
.tx-value.big { font-size:23px; color:var(--lightning); text-shadow:0 0 20px rgba(255,229,102,0.4); }
.tx-divider { height:1px; background:var(--border); }

/* QR */
.qr-area { display:flex; flex-direction:column; align-items:center; gap:9px; }
.qr-wrap {
  background:#fff; border-radius:12px; padding:9px;
  box-shadow:0 0 40px rgba(245,166,35,0.2);
  position:relative; display:inline-block;
}
.qr-corner { position:absolute; width:13px; height:13px; border-color:var(--accent); border-style:solid; }
.qr-corner.tl { top:-2px; left:-2px;   border-width:3px 0 0 3px; border-radius:3px 0 0 0; }
.qr-corner.tr { top:-2px; right:-2px;  border-width:3px 3px 0 0; border-radius:0 3px 0 0; }
.qr-corner.bl { bottom:-2px; left:-2px;  border-width:0 0 3px 3px; border-radius:0 0 0 3px; }
.qr-corner.br { bottom:-2px; right:-2px; border-width:0 3px 3px 0; border-radius:0 0 3px 0; }
.qr-hint { font-size:10px; color:var(--muted); text-align:center; }

/* COUNTDOWN */
.countdown-wrap { display:flex; flex-direction:column; gap:5px; }
.countdown-bar-bg { height:4px; background:var(--surface2); border-radius:2px; overflow:hidden; }
.countdown-bar { height:100%; border-radius:2px; background:var(--accent); transition:width 1s linear, background 1s; box-shadow:0 0 8px var(--accent); }
.countdown-text { font-family:var(--mono); font-size:10px; color:var(--muted); text-align:right; }

/* PAID OVERLAY */
.paid-overlay {
  position:absolute; inset:0; background:rgba(10,14,23,0.93);
  display:flex; flex-direction:column; align-items:center; justify-content:center;
  gap:12px; border-radius:14px; opacity:0; pointer-events:none; transition:opacity 0.4s; z-index:20;
}
.paid-overlay.show { opacity:1; pointer-events:all; }
.paid-icon { font-size:48px; animation:pop-in 0.4s cubic-bezier(0.34,1.56,0.64,1); }
@keyframes pop-in { from{transform:scale(0)} to{transform:scale(1)} }
.paid-text { font-size:23px; font-weight:700; color:var(--green); text-shadow:0 0 30px var(--green); }
.paid-sub  { font-family:var(--mono); font-size:12px; color:var(--muted); }

/* RIGHT */
.right {
  background:var(--surface); padding:22px 19px;
  display:flex; flex-direction:column; gap:16px; overflow-y:auto;
}
.onboard-title   { font-size:10px; text-transform:uppercase; letter-spacing:0.15em; color:var(--muted); margin-bottom:3px; }
.onboard-heading { font-size:17px; font-weight:700; color:var(--text); line-height:1.2; }
.onboard-sub     { font-size:12px; color:var(--muted); line-height:1.5; margin-top:5px; }
.divider         { height:1px; background:var(--border); flex-shrink:0; }
.blink-qr-wrap   { display:flex; flex-direction:column; align-items:center; gap:8px; }
.blink-qr-box    { background:#fff; border-radius:10px; padding:8px; width:126px; height:126px; display:flex; align-items:center; justify-content:center; }
.blink-url       { font-family:var(--mono); font-size:11px; color:var(--accent); text-align:center; }
.blink-badge {
  display:flex; align-items:flex-start; gap:10px;
  background:rgba(245,166,35,0.07); border:1px solid rgba(245,166,35,0.18);
  border-radius:8px; padding:11px;
}
.blink-badge-icon { font-size:18px; flex-shrink:0; }
.blink-badge-text { font-size:11px; color:var(--muted); line-height:1.5; }
.blink-badge-text strong { color:var(--accent2); display:block; font-size:12px; margin-bottom:1px; }

#active-session { display:none; flex-direction:column; gap:16px; flex:1; }
#idle-steps     { display:flex; flex-direction:column; }
</style>
</head>
<body>

<!-- SETTINGS OVERLAY -->
<div class="settings-overlay" id="settings-overlay">
  <div class="settings-panel">
    <div>
      <div class="settings-title">&#x2699;&#xFE0F; ATM Settings</div>
      <div class="settings-subtitle">Saved to ESP32 flash &mdash; not visible to buyers</div>
    </div>
    <div class="form-section">
      <div class="form-section-label">&#x1F4F6; WiFi &mdash; internet connection</div>
      <div class="form-row">
        <label class="form-label">Network name (SSID)</label>
        <input class="form-input" id="f-ssid" type="text" placeholder="e.g. MyPhone Hotspot" autocomplete="off" spellcheck="false">
      </div>
      <div class="form-row">
        <label class="form-label">Password</label>
        <div class="pw-wrap">
          <input class="form-input" id="f-password" type="password" placeholder="WiFi password" autocomplete="off">
          <button class="pw-toggle" onclick="togglePw('f-password',this)">&#128065;</button>
        </div>
      </div>
    </div>
    <div class="form-section">
      <div class="form-section-label">&#x26A1; Blink wallet</div>
      <div class="form-row">
        <label class="form-label">Wallet ID</label>
        <input class="form-input" id="f-walletid" type="text" placeholder="Your Blink wallet ID" autocomplete="off" spellcheck="false">
      </div>
      <div class="form-row">
        <label class="form-label">API Key</label>
        <div class="pw-wrap">
          <input class="form-input" id="f-apikey" type="password" placeholder="Your Blink API key" autocomplete="off">
          <button class="pw-toggle" onclick="togglePw('f-apikey',this)">&#128065;</button>
        </div>
      </div>
    </div>
    <div class="settings-status" id="settings-status">Enter credentials above to get started</div>
    <div class="btn-row">
      <button class="btn danger sm" onclick="factoryReset()">Factory Reset</button>
      <button class="btn sm" id="close-btn" onclick="closeSettings()" style="display:none">Close</button>
      <button class="btn primary" id="save-btn" onclick="saveSettings()">Save &amp; Connect</button>
    </div>
    <div class="long-press-hint">Hold the &#x26A1; logo for 3 seconds to return here</div>
  </div>
</div>

<!-- TOP BAR -->
<div class="topbar">
  <div class="topbar-left">
    <div class="logo" id="logo-hold">
      <span class="bolt">&#x26A1;</span>SATS ATM
    </div>
    <div class="rate-badge">
      <div class="rate-dot" id="rate-dot"></div>
      <span id="rate-display">&#8364;1.00 = &mdash; sats</span>
    </div>
  </div>
  <div class="gauge-wrap">
    <span class="gauge-label">Wallet</span>
    <div class="gauge-segments">
      <div class="seg empty" id="seg1"></div>
      <div class="seg empty" id="seg2"></div>
      <div class="seg empty" id="seg3"></div>
    </div>
  </div>
</div>

<!-- MAIN -->
<div class="main">
  <div class="left">

    <div class="idle-screen" id="idle-screen">
      <div class="idle-bolt">&#x26A1;</div>
      <div class="idle-title">Buy Bitcoin</div>
      <div class="idle-sub">Insert coins to get started</div>
    </div>

    <div id="idle-steps">
      <div class="steps-title">How it works</div>
      <div class="steps">
        <div class="step"><div class="step-num">1</div><div><div class="step-text">Insert coins</div><div class="step-sub">Maximum &#8364;10 per session</div></div></div>
        <div class="step"><div class="step-num">2</div><div><div class="step-text">Scan QR with Blink wallet</div><div class="step-sub">Point your camera at the code</div></div></div>
        <div class="step"><div class="step-num">3</div><div><div class="step-text">Receive your SATs</div><div class="step-sub">Sent instantly over Lightning</div></div></div>
      </div>
    </div>

    <div id="active-session">
      <div>
        <div class="steps-title">How it works</div>
        <div class="steps">
          <div class="step done" id="step1"><div class="step-num" id="sn1">&#10003;</div><div><div class="step-text">Insert coins</div><div class="step-sub">Maximum &#8364;10 per session</div></div></div>
          <div class="step active" id="step2"><div class="step-num" id="sn2">2</div><div><div class="step-text">Scan QR with Blink wallet</div><div class="step-sub">Point your camera at the code below</div></div></div>
          <div class="step" id="step3"><div class="step-num" id="sn3">3</div><div><div class="step-text">Receive your SATs</div><div class="step-sub">Sent instantly over Lightning</div></div></div>
        </div>
      </div>

      <div class="tx-panel" id="tx-panel">
        <div class="paid-overlay" id="paid-overlay">
          <div class="paid-icon">&#9989;</div>
          <div class="paid-text">Payment Received!</div>
          <div class="paid-sub" id="paid-sub">sats sent</div>
        </div>
        <div class="tx-row"><div class="tx-label">You inserted</div><div class="tx-value" id="credit-display">&#8364;0.00</div></div>
        <div class="tx-divider"></div>
        <div class="tx-row"><div class="tx-label">You receive</div><div class="tx-value big" id="sats-display">0 sats</div></div>
        <div class="tx-divider"></div>
        <div class="qr-area">
          <div class="qr-wrap">
            <div class="qr-corner tl"></div><div class="qr-corner tr"></div>
            <div class="qr-corner bl"></div><div class="qr-corner br"></div>
            <div id="qrcode"></div>
          </div>
          <div class="qr-hint">Scan with your Lightning wallet to receive sats</div>
        </div>
        <div class="countdown-wrap">
          <div class="countdown-bar-bg"><div class="countdown-bar" id="cbar" style="width:100%"></div></div>
          <div class="countdown-text" id="ctext">Session expires in 60s</div>
        </div>
      </div>
    </div>

  </div>

  <!-- RIGHT — permanent onboarding panel -->
  <div class="right">
    <div>
      <div class="onboard-title">New to Bitcoin?</div>
      <div class="onboard-heading">Get a free<br>Lightning wallet</div>
      <div class="onboard-sub">Download Blink &mdash; free, easy, ready in 60 seconds.</div>
    </div>
    <div class="divider"></div>
    <div class="blink-qr-wrap">
      <div class="blink-qr-box" id="blink-qr"></div>
      <div class="blink-url">blink.sv/download</div>
    </div>
    <div class="divider"></div>
    <div class="blink-badge">
      <div class="blink-badge-icon">&#x26A1;</div>
      <div class="blink-badge-text">
        <strong>Blink Wallet</strong>
        Free &middot; No bank needed &middot; Instant Lightning payments
      </div>
    </div>
  </div>
</div>

<!-- INLINED QR LIBRARY (davidshimjs/qrcodejs MIT) -->
<script>
var QRCode;!function(){function a(a){this.mode=c.MODE_8BIT_BYTE,this.data=a,this.parsedData=[];for(var b=[],d=0,e=this.data.length;e>d;d++){var f=this.data.charCodeAt(d);if(f>65536)b[0]=240|(1835008&f)>>>18,b[1]=128|(258048&f)>>>12,b[2]=128|(4032&f)>>>6,b[3]=128|63&f;else if(f>2048)b[0]=224|(61440&f)>>>12,b[1]=128|(4032&f)>>>6,b[2]=128|63&f;else if(f>128)b[0]=192|(1984&f)>>>6,b[1]=128|63&f;else b[0]=f;this.parsedData=this.parsedData.concat(b)}this.parsedData.length!=this.data.length&&(this.parsedData.unshift(191),this.parsedData.unshift(187),this.parsedData.unshift(239))}function b(a,b){this.typeNumber=a,this.errorCorrectLevel=b,this.modules=null,this.moduleCount=0,this.dataCache=null,this.dataList=[]}function i(a,b){if(void 0==a.length)throw new Error(a.length);for(var c=0,d=0;d<a.length;d++)c+=a[d]<<8*(a.length-d-1);this.num=c}function j(a){this.gexp=[],this.glog=[];for(var b=1,c=0;256>c;c++)this.gexp[c]=b,b<<=1,b>=256&&(b^=285);for(var c=0;255>c;c++)this.glog[this.gexp[c]]=c;for(var d=[],e=0;e<a;e++)d[e]=0;d[0]=1;for(var e=0;a>e;e++){for(var f=[],g=0;g<d.length+1;g++)f[g]=0;for(var g=0;g<d.length;g++)for(var h=0;h<2;h++)f[g+h]^=this.gexp[(this.glog[d[g]]+e)%255];d=f}this.num=d}function k(a,b){for(var c=b.num.length,d=[],e=0;e<a.num.length-b.num.length+1;e++){var f=this.glog[a.num[e]];a.num[e]=0;for(var g=0;g<b.num.length;g++)a.num[e+g]^=this.gexp[(f+this.glog[b.num[g]])%255]}return new j(0)}function n(a,b){var c=-1;switch(b){case 1:c=[],c[1]=1,c[7]=26,c[8]=19,c[13]=25;break;case 0:c=[],c[1]=0,c[7]=20,c[8]=10,c[13]=17}return c[a]}a.prototype={getLength:function(){return this.parsedData.length},write:function(a){for(var b=0,c=this.parsedData.length;c>b;b++)a.put(this.parsedData[b],8)}};var c={MODE_NUMBER:1,MODE_ALPHA_NUM:2,MODE_8BIT_BYTE:4,MODE_KANJI:8},d={L:1,M:0,Q:3,H:2},e={PATTERN000:0,PATTERN001:1,PATTERN010:2,PATTERN011:3,PATTERN100:4,PATTERN101:5,PATTERN110:6,PATTERN111:7};b.prototype={addData:function(b){var c=new a(b);this.dataList.push(c),this.dataCache=null},isDark:function(a,b){if(0>a||this.moduleCount<=a||0>b||this.moduleCount<=b)throw new Error(a+","+b);return this.modules[a][b]},getModuleCount:function(){return this.moduleCount},make:function(){this.makeImpl(!1,this.getBestMaskPattern())},makeImpl:function(a,c){this.moduleCount=4*this.typeNumber+17,this.modules=function(a){var b=[];for(var c=0;a>c;c++){b[c]=[];for(var d=0;a>d;d++)b[c][d]=null}return b}(this.moduleCount),this.setupPositionProbePattern(0,0),this.setupPositionProbePattern(this.moduleCount-7,0),this.setupPositionProbePattern(0,this.moduleCount-7),this.setupPositionAdjustPattern(),this.setupTimingPattern(),this.setupTypeInfo(a,c),this.typeNumber>=7&&this.setupTypeNumber(a),null==this.dataCache&&(this.dataCache=b.createData(this.typeNumber,this.errorCorrectLevel,this.dataList)),this.mapData(this.dataCache,c)},setupPositionProbePattern:function(a,b){for(var c=-1;7>=c;c++)if(!(-1>=a+c||this.moduleCount<=a+c))for(var d=-1;7>=d;d++)-1>=b+d||this.moduleCount<=b+d||(this.modules[a+c][b+d]=c>=0&&6>=c&&(0==d||6==d)||d>=0&&6>=d&&(0==c||6==c)||c>=2&&4>=c&&d>=2&&4>=d?!0:!1)},getBestMaskPattern:function(){for(var a=0,b=0,c=0;8>c;c++){this.makeImpl(!0,c);var d=f.getLostPoint(this);(0==c||a>d)&&(a=d,b=c)}return b},setupTimingPattern:function(){for(var a=8;this.moduleCount-8>a;a++)null==this.modules[a][6]&&(this.modules[a][6]=0==a%2);for(var b=8;this.moduleCount-8>b;b++)null==this.modules[6][b]&&(this.modules[6][b]=0==b%2)},setupPositionAdjustPattern:function(){for(var a=g.getPatternPosition(this.typeNumber),b=0;b<a.length;b++)for(var c=0;c<a.length;c++){var d=a[b],e=a[c];if(null==this.modules[d][e])for(var f=-2;2>=f;f++)for(var h=-2;2>=h;h++)this.modules[d+f][e+h]=-2==f||2==f||-2==h||2==h||0==f&&0==h?!0:!1}},setupTypeNumber:function(a){for(var b=h.getBCHTypeNumber(this.typeNumber),c=0;18>c;c++){var d=!a&&1==(b>>c&1);this.modules[Math.floor(c/3)][c%3+this.moduleCount-8-3]=d}for(var c=0;18>c;c++){var d=!a&&1==(b>>c&1);this.modules[c%3+this.moduleCount-8-3][Math.floor(c/3)]=d}},setupTypeInfo:function(a,b){for(var c=d[this.errorCorrectLevel]<<3|b,e=h.getBCHTypeInfo(c),f=0;15>f;f++){var g=!a&&1==(e>>f&1);6>f?this.modules[f][8]=g:7>f?this.modules[f+1][8]=g:this.modules[this.moduleCount-15+f][8]=g}for(var f=0;15>f;f++){var g=!a&&1==(e>>f&1);8>f?this.modules[8][this.moduleCount-f-1]=g:9>f?this.modules[8][15-f-1+1]=g:this.modules[8][15-f-1]=g}this.modules[this.moduleCount-8][8]=!a},mapData:function(a,b){for(var c=-1,d=this.moduleCount-1,e=7,g=0,h=this.moduleCount-1;h>0;h-=2)for(6==h&&h--;;){for(var i=0;2>i;i++)if(null==this.modules[d][h-i]){var j=!1;g<a.length&&(j=1==(a[g]>>>e&1)),f.getMask(b,d,h-i)&&(j=!j),this.modules[d][h-i]=j,e--,-1==e&&(g++,e=7)}if(d+=c,0>d||this.moduleCount<=d){d-=c,c=-c;break}}}};var f={getBCHDigit:function(a){for(var b=0;0!=a;)b++,a>>>=1;return b},getBCHTypeInfo:function(a){for(var b=a<<10;f.getBCHDigit(b)-f.getBCHDigit(1335)>=0;)b^=1335<<f.getBCHDigit(b)-f.getBCHDigit(1335);return 21522^(a<<10|b)},getBCHTypeNumber:function(a){for(var b=a<<12;f.getBCHDigit(b)-f.getBCHDigit(7973)>=0;)b^=7973<<f.getBCHDigit(b)-f.getBCHDigit(7973);return a<<12|b},getPatternPosition:function(a){return n(a,1)},getMask:function(a,b,c){switch(a){case e.PATTERN000:return 0==(b+c)%2;case e.PATTERN001:return 0==b%2;case e.PATTERN010:return 0==c%3;case e.PATTERN011:return 0==(b+c)%3;case e.PATTERN100:return 0==(Math.floor(b/2)+Math.floor(c/3))%2;case e.PATTERN101:return 0==b*c%2+b*c%3;case e.PATTERN110:return 0==(b*c%2+b*c%3)%2;case e.PATTERN111:return 0==(b*c%3+(b+c)%2)%2;default:throw new Error("bad maskPattern:"+a)}},getLostPoint:function(a){for(var b=a.getModuleCount(),c=0,d=0;b>d;d++)for(var e=0;b>e;e++){for(var g=0,h=a.isDark(d,e),i=-1;1>=i;i++)if(!(0>d+i||b<=d+i))for(var j=-1;1>=j;j++)0>e+j||b<=e+j||(d+i!=d||e+j!=e)&&h==a.isDark(d+i,e+j)&&g++;g>5&&(c+=3+g-5)}for(var d=0;b-1>d;d++)for(var e=0;b-1>e;e++){var k=0;a.isDark(d,e)&&k++,a.isDark(d+1,e)&&k++,a.isDark(d,e+1)&&k++,a.isDark(d+1,e+1)&&k++,(0==k||4==k)&&(c+=3)}for(var d=0;b>d;d++)for(var e=0;b-6>e;e++)a.isDark(d,e)&&!a.isDark(d,e+1)&&a.isDark(d,e+2)&&a.isDark(d,e+3)&&a.isDark(d,e+4)&&!a.isDark(d,e+5)&&a.isDark(d,e+6)&&(c+=40);for(var e=0;b>e;e++)for(var d=0;b-6>d;d++)a.isDark(d,e)&&!a.isDark(d+1,e)&&a.isDark(d+2,e)&&a.isDark(d+3,e)&&a.isDark(d+4,e)&&!a.isDark(d+5,e)&&a.isDark(d+6,e)&&(c+=40);for(var l=0,d=0;b>d;d++)for(var e=0;b>e;e++)a.isDark(d,e)&&l++;var m=Math.abs(100*l/b/b-50)/5;return c+=10*m},createData:function(a,b,c){for(var e=p.getRSBlocks(a,b),f=new o,g=0;g<c.length;g++){var h=c[g];f.put(h.mode,4),f.put(h.getLength(),q.getLengthInBits(h.mode,a)),h.write(f)}for(var i=0,g=0;g<e.length;g++)i+=e[g].dataCount;if(f.getLengthInBits()>8*i)throw new Error("code length overflow. ("+f.getLengthInBits()+">"+8*i+")");for(f.getLengthInBits()+4<=8*i&&f.put(0,4);0!=f.getLengthInBits()%8;)f.putBit(!1);for(;;){if(f.getLengthInBits()>=8*i)break;if(f.put(236,8),f.getLengthInBits()>=8*i)break;f.put(17,8)}return b.createBytes(f,e)},createBytes:function(a,b){for(var c=0,d=0,e=0,f=new Array(b.length),g=new Array(b.length),h=0;h<b.length;h++){var i=b[h].dataCount,l=b[h].totalCount-i;d=Math.max(d,i),e=Math.max(e,l),f[h]=new Array(i);for(var m=0;m<f[h].length;m++)f[h][m]=255&a.buffer[c++];g[h]=new Array(l);for(var m=0;m<g[h].length;m++)g[h][m]=0}var n=new Array(e),k=0;for(var h=0;h<b.length;h++)for(var m=0;m<b[h].totalCount-b[h].dataCount;m++)g[h][m]=0;var o=[],m=0;for(;d>m;m++)for(var h=0;h<b.length;h++)m<f[h].length&&(o[k++]=f[h][m]);for(var m=0;e>m;m++)for(var h=0;h<b.length;h++)m<g[h].length&&(o[k++]=g[h][m]);return o}};i.prototype={get:function(a){return 1==(this.num>>>a&1)},getLengthInBits:function(){return this.num},put:function(a,b){for(var c=0;b>c;c++)this.putBit(this.get(b-c-1),a)},putBit:function(a){var b=Math.floor(this.num/8);this.buffer.length<=b&&this.buffer.push(0),a&&(this.buffer[b]|=128>>>this.num%8),this.num++}};var g={getPatternPosition:function(a){return n(a,0)},getLostPoint:function(a){return f.getLostPoint(a)},getBCHTypeInfo:function(a){return f.getBCHTypeInfo(a)},getBCHTypeNumber:function(a){return f.getBCHTypeNumber(a)},getBCHDigit:function(a){return f.getBCHDigit(a)}},h={getBCHTypeInfo:function(a){return f.getBCHTypeInfo(a)},getBCHTypeNumber:function(a){return f.getBCHTypeNumber(a)}};var o=function(){this.buffer=[],this.num=0};o.prototype={get:function(a){var b=Math.floor(a/8);return 1==(this.buffer[b]>>>7-a%8&1)},put:function(a,b){for(var c=0;b>c;c++)this.putBit(1==(a>>>b-c-1&1))},getLengthInBits:function(){return this.num},putBit:function(a){var b=Math.floor(this.num/8);this.buffer.length<=b&&this.buffer.push(0),a&&(this.buffer[b]|=128>>>this.num%8),this.num++}};var p={getRSBlocks:function(a,b){var c=p.getRSBlockTable(a,b);if(void 0==c)throw new Error("bad rs block @ typeNumber:"+a+"/errorCorrectLevel:"+b);for(var d=c.length/3,e=[],f=0;d>f;f++)for(var g=c[3*f+0],h=c[3*f+1],i=c[3*f+2],j=0;g>j;j++)e.push(new q(h,i));return e},getRSBlockTable:function(a,b){switch(b){case d.L:return n(a,0);case d.M:return n(a,1);case d.Q:return n(a,2);case d.H:return n(a,3)}}};var q=function(a,b){this.totalCount=a,this.dataCount=b};q.getLengthInBits=function(a,b){switch(a){case c.MODE_NUMBER:return 10>b?10:27>b?12:14;case c.MODE_ALPHA_NUM:return 10>b?9:27>b?11:13;case c.MODE_8BIT_BYTE:return 10>b?8:16;case c.MODE_KANJI:return 10>b?8:27>b?10:12;default:throw new Error("mode:"+a)}};var r=function(a,b,c){this.el=a,this.htOption={width:256,height:256,typeNumber:4,colorDark:"#000000",colorLight:"#ffffff",correctLevel:d.H};if(b){"string"==typeof b&&(b={text:b});for(var e in b)this.htOption[e]=b[e]}if("string"==typeof a&&(this.el=document.getElementById(a)),this.htOption.useSVG)this.oQRCode=null;else{this.oQRCode=new b(this.htOption.typeNumber,this.htOption.correctLevel),this.oQRCode.addData(this.htOption.text),this.oQRCode.make()}c?this._oDrawing=new c(this.el,this.htOption):this._oDrawing=new s(this.el,this.htOption),this._oDrawing.draw(this.oQRCode)};r.prototype.makeCode=function(a){this.oQRCode.addData(a),this.oQRCode.make(),this._oDrawing.draw(this.oQRCode)};var s=function(a,b){this._bIsPainted=!1,this._htOption=b;var c=document.createElement("canvas");c.width=b.width,c.height=b.height,a.appendChild(c),this._elCanvas=c,this._oContext=c.getContext("2d"),this._oContext.fillStyle=b.colorLight,this._oContext.fillRect(0,0,b.width,b.height)};s.prototype.draw=function(a){var b=this._htOption,c=this._oContext,d=a.getModuleCount(),e=Math.floor(b.width/d),f=Math.floor(b.height/d);c.fillStyle=b.colorLight,c.fillRect(0,0,b.width,b.height);for(var g=0;d>g;g++)for(var h=0;d>h;h++){var i=a.isDark(g,h);c.fillStyle=i?b.colorDark:b.colorLight,c.fillRect(h*e,g*f,e,f)}this._bIsPainted=!0},s.prototype.clear=function(){this._oContext.clearRect(0,0,this._elCanvas.width,this._elCanvas.height),this._bIsPainted=!1};QRCode=r}();
</script>

<!-- APP LOGIC -->
<script>
const POLL_MS   = 2000;
const SESSION_S = 60;

let sessionActive = false;
let countdownVal  = SESSION_S;
let countdownInt  = null;
let qrGenerated   = false;
let lastInvoice   = '';
let lastState     = '';
let paidShown     = false;
let settingsOpen  = false;

// Static Blink download QR — generated once on load
new QRCode(document.getElementById('blink-qr'), {
  text: 'https://blink.sv/download',
  width: 114, height: 114,
  colorDark: '#000000', colorLight: '#ffffff',
  correctLevel: QRCode.CorrectLevel.M
});

// ── Long-press logo 3s → settings ────────────────────
(function(){
  const el = document.getElementById('logo-hold');
  let t = null;
  function start(){ t = setTimeout(()=>openSettings(true), 3000); }
  function cancel(){ clearTimeout(t); }
  el.addEventListener('mousedown',  start);
  el.addEventListener('touchstart', start, {passive:true});
  el.addEventListener('mouseup',    cancel);
  el.addEventListener('mouseleave', cancel);
  el.addEventListener('touchend',   cancel);
})();

// ── Settings ──────────────────────────────────────────
function openSettings(canClose) {
  settingsOpen = true;
  document.getElementById('settings-overlay').classList.add('show');
  document.getElementById('close-btn').style.display = canClose ? 'inline-block' : 'none';
}
function closeSettings() {
  document.getElementById('settings-overlay').classList.remove('show');
  settingsOpen = false;
}
function togglePw(id, btn) {
  const el = document.getElementById(id);
  el.type = el.type === 'password' ? 'text' : 'password';
  btn.textContent = el.type === 'password' ? '\uD83D\uDC41' : '\uD83D\uDE48';
}

async function saveSettings() {
  const ssid     = document.getElementById('f-ssid').value.trim();
  const password = document.getElementById('f-password').value;
  const walletId = document.getElementById('f-walletid').value.trim();
  const apiKey   = document.getElementById('f-apikey').value.trim();

  if (!ssid || !walletId || !apiKey) {
    return setStatus('fail', 'SSID, Wallet ID and API Key are required');
  }
  const btn = document.getElementById('save-btn');
  btn.disabled = true;
  setStatus('busy', 'Testing WiFi connection\u2026');

  try {
    const r = await fetch('/settings', {
      method: 'POST',
      headers: { 'Content-Type': 'application/json' },
      body: JSON.stringify({ ssid, password, walletId, apiKey })
    });
    const d = await r.json();
    if (d.success) {
      setStatus('ok', 'Saved! ESP32 rebooting\u2026');
      setTimeout(() => location.reload(), 4000);
    } else {
      setStatus('fail', d.error || 'Connection failed \u2014 check credentials');
      btn.disabled = false;
    }
  } catch(e) {
    setStatus('fail', 'Cannot reach ESP32');
    btn.disabled = false;
  }
}

async function factoryReset() {
  if (!confirm('Clear all saved settings and reboot?')) return;
  try {
    await fetch('/reset', { method:'POST' });
    setStatus('ok', 'Reset complete \u2014 rebooting\u2026');
  } catch(e) { setStatus('fail', 'Cannot reach ESP32'); }
}

function setStatus(type, msg) {
  const el = document.getElementById('settings-status');
  el.className = 'settings-status' + (type ? ' '+type : '');
  el.textContent = msg;
}

// ── Gauge ─────────────────────────────────────────────
function setGauge(level) {
  const s = [1,2,3].map(n => document.getElementById('seg'+n));
  s.forEach(el => el.className = 'seg empty');
  if      (level==='high')     { s[0].className='seg green'; s[1].className='seg green'; s[2].className='seg green'; }
  else if (level==='mid')      { s[0].className='seg amber'; s[1].className='seg amber'; }
  else if (level==='low')      { s[0].className='seg red'; }
  else if (level==='critical') { s[0].className='seg flash'; }
}

// ── Countdown ─────────────────────────────────────────
function startCountdown() {
  countdownVal = SESSION_S;
  clearInterval(countdownInt);
  const bar = document.getElementById('cbar');
  const txt = document.getElementById('ctext');
  countdownInt = setInterval(() => {
    countdownVal--;
    const pct = (countdownVal / SESSION_S) * 100;
    const col = countdownVal > 20 ? 'var(--accent)' : countdownVal > 10 ? 'var(--amber)' : 'var(--red)';
    bar.style.width = pct+'%'; bar.style.background = col; bar.style.boxShadow = '0 0 8px '+col;
    txt.textContent = 'Session expires in '+countdownVal+'s';
    if (countdownVal <= 0) clearInterval(countdownInt);
  }, 1000);
}

// ── Show active session ───────────────────────────────
function showQR(invoice, sats, credit) {
  document.getElementById('credit-display').textContent = '\u20AC'+parseFloat(credit).toFixed(2);
  document.getElementById('sats-display').textContent   = parseInt(sats).toLocaleString()+' sats';
  document.getElementById('paid-sub').textContent       = parseInt(sats).toLocaleString()+' sats sent';

  if (!qrGenerated || invoice !== lastInvoice) {
    document.getElementById('qrcode').innerHTML = '';
    new QRCode(document.getElementById('qrcode'), {
      text: 'lightning:'+invoice,
      width: 162, height: 162,
      colorDark: '#000000', colorLight: '#ffffff',
      correctLevel: QRCode.CorrectLevel.M
    });
    qrGenerated = true; lastInvoice = invoice;
    startCountdown();
  }

  document.getElementById('idle-screen').classList.add('hidden');
  document.getElementById('idle-steps').style.display     = 'none';
  document.getElementById('active-session').style.display = 'flex';
}

// ── Paid ──────────────────────────────────────────────
function showPaid() {
  clearInterval(countdownInt);
  document.getElementById('step2').className = 'step done';
  document.getElementById('sn2').textContent = '\u2713';
  document.getElementById('step3').className = 'step active';
  document.getElementById('paid-overlay').classList.add('show');
  setTimeout(() => {
    document.getElementById('step3').className = 'step done';
    document.getElementById('sn3').textContent  = '\u2713';
  }, 600);
}

// ── Reset ─────────────────────────────────────────────
function resetToIdle() {
  clearInterval(countdownInt);
  qrGenerated = false; lastInvoice = ''; paidShown = false;
  document.getElementById('paid-overlay').classList.remove('show');
  document.getElementById('active-session').style.display = 'none';
  document.getElementById('idle-screen').classList.remove('hidden');
  document.getElementById('idle-steps').style.display     = 'flex';
  document.getElementById('qrcode').innerHTML             = '';
  document.getElementById('step1').className='step done'; document.getElementById('sn1').textContent='\u2713';
  document.getElementById('step2').className='step active'; document.getElementById('sn2').textContent='2';
  document.getElementById('step3').className='step'; document.getElementById('sn3').textContent='3';
  const bar = document.getElementById('cbar');
  bar.style.width='100%'; bar.style.background='var(--accent)';
  document.getElementById('ctext').textContent='Session expires in '+SESSION_S+'s';
}

// ── Poll /state every 2s ──────────────────────────────
async function pollState() {
  if (settingsOpen) return;
  try {
    const r = await fetch('/state');
    if (!r.ok) return;
    const d = await r.json();

    // First load with no credentials → open settings
    if (d.settings === true && lastState === '') openSettings(false);

    // Rate display
    if (d.rate > 0) {
      document.getElementById('rate-display').textContent =
        '\u20AC1.00 = '+parseInt(d.rate).toLocaleString()+' sats';
    }

    // Connection dot
    const dot = document.getElementById('rate-dot');
    const ok  = d.rate > 0;
    dot.style.background = ok ? 'var(--green)' : 'var(--red)';
    dot.style.boxShadow  = ok ? '0 0 6px var(--green)' : '0 0 6px var(--red)';

    // Gauge
    if (d.gauge) setGauge(d.gauge);

    // UI state
    if      (d.state === 'SHOW_QR' && d.invoice) { paidShown=false; showQR(d.invoice, d.sats, d.credit); }
    else if (d.state === 'PAID' && !paidShown)   { paidShown=true; showPaid(); setTimeout(resetToIdle, 4000); }
    else if (d.state === 'IDLE' && lastState && lastState !== 'IDLE') { resetToIdle(); }

    lastState = d.state;
  } catch(e) { /* ESP32 unreachable — hold last UI state */ }
}

pollState();
setInterval(pollState, POLL_MS);
</script>
</body>
</html>
)rawhtml";

// Returns UI HTML from PROGMEM as an Arduino String
String getUI() {
  return String(FPSTR(UI_HTML));
}
